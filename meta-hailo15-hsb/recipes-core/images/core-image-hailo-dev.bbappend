IMAGE_INSTALL:append = " packagegroup-hailo15-hsb"
